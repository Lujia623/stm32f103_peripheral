# Keil uVision project workspace.uvprojx, settings and files
target Workspace (5060960::V5.06 update 7 (build 960)::.\ARMCompiler506)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: workspace +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CoreSupport;..\Bsp\inc;..\User;..\Lib\utils;..\FreeRTOS\include;..\FreeRTOS\ports\ARM_CM3;..\Bsp\w5500;..\lwip_2.1.2\include;..\lwip_2.1.2\include\compat;..\lwip_2.1.2\include\lwip;..\lwip_2.1.2\include\netif;..\lwip_2.1.2\include\lwip\apps;..\lwip_2.1.2\include\lwip\priv;..\lwip_2.1.2\include\lwip\prot;..\lwip_2.1.2\include\arch;..\User\arch;..\easylogger\inc;..\User\Application\inc;..\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Starup
    ../Libraries/CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_it.c
  group User
    ../User/: main.c
    ../Bsp/w5500/: w5500.c wizchip_conf.c ethernetif.c
  group Bsp
    ../Bsp/src/: led.c bsp_key.c bsp_system.c bsp_serial.c bsp_usart.c bsp_systick.c bsp_eth.c
  group LwIP/api
    ../lwip_2.1.2/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../lwip_2.1.2/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip_2.1.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../lwip_2.1.2/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LwIP/arch
    ../User/arch/: sys_arch.c
  group FreeRTOS/src
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/ports/MemMang/: heap_4.c
    ../FreeRTOS/ports/ARM_CM3/: port.c
  group Middle/elog
    ../easylogger/src/: elog.c elog_utils.c
    ../easylogger/port/: elog_port.c
  group Application
    ../User/Application/: client.c
  group SEGGER_RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
